# Autodesk Inventor assembly: 21.1020 BUTT FASTENER
## iProperties
Created: 2006-12
Part Number: 21.1020 BUTT FASTENER
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
